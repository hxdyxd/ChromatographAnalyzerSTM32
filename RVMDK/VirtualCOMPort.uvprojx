# Keil uVision project VirtualCOMPort.uvprojx, settings and files
target ChromatographAnalyzer (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.0.0
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: STM3210E-EVAL
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER, STM32F10X_MD
  c include: ..\inc;..\Libraries\CMSIS;..\Libraries\STM32_USB-FS-Device_Driver\inc;..\Libraries\STM32F10x_StdPeriph_Driver\inc;..\src\hardware;..\src\hardware\ad7190_generic;..\src\app;..\src\hal;..\src\app\api
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group RVMDK
    ../Libraries/CMSIS/startup/: startup_stm32f10x_md.s
  group CMSIS
    ../Libraries/CMSIS/: core_cm3.c system_stm32f10x.c
  group StdPeriph_Driver
    ../Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group USB-FS-Device_Driver
    ../Libraries/STM32_USB-FS-Device_Driver/src/: usb_core.c usb_init.c usb_int.c usb_mem.c usb_regs.c
  group VirtualCOMPort
    ../src/hardware/VirtualCOMPort/: hw_config.c usb_desc.c usb_endp.c usb_istr.c usb_prop.c usb_pwr.c
  group Hardware
    ../src/hardware/: stm32f10x_it.c systick.c leds.c stm32_spi.c
  group HAL
    ../src/hal/: data_interface_hal.c
  group ad7190_generic
    ../src/hardware/ad7190_generic/: AD7190.c Communication.c TIME.c
  group APP
    ../src/app/: main.c gain.c channel.c soft_timer.c
    ../src/app/api/: interface_api.c
  group Doc
    ../: readme.txt
